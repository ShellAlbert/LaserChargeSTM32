# Keil uVision project LarserChargeFW.uvprojx, settings and files
target LarserChargeFW (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: LarserChargeFW
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LibJPEG/include;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash.c stm32f4xx_hal_can.c stm32f4xx_hal_eth.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c tcpip.c api_msg.c netbuf.c netdb.c err.c sockets.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipv6cp.c eap.c lcp.c vj.c multilink.c pppoe.c chap-md5.c eui64.c ccp.c ipcp.c demand.c upap.c ecp.c magic.c pppol2tp.c mppe.c pppcrypt.c utils.c pppos.c fsm.c chap-new.c chap_ms.c pppapi.c ppp.c auth.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c dhcp.c icmp.c etharp.c ip4.c igmp.c autoip.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/: sys.c stats.c netif.c pbuf.c tcp_out.c tcp_in.c ip.c udp.c init.c inet_chksum.c timeouts.c def.c tcp.c memp.c dns.c mem.c raw.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: inet6.c ip6_frag.c nd6.c ip6_addr.c ethip6.c ip6.c mld6.c icmp6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: sha1.c des.c arc4.c md5.c md4.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/User
    ../Src/: stm32f4xx_it.c rng.c usart.c i2c.c jdata_conf.c stm32f4xx_hal_msp.c main.c fatfs.c rtc.c can.c libjpeg.c freertos.c usbh_conf.c usb_host.c user_diskio.c ethernetif.c stm32f4xx_hal_timebase_TIM.c gpio.c fsmc.c lwip.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jidctflt.c jcinit.c jfdctint.c jcomapi.c jdmaster.c jdsample.c jcmaster.c jdmerge.c jcsample.c jdcolor.c jmemmgr.c jdapimin.c jccolor.c jidctfst.c jdhuff.c jdapistd.c jdatasrc.c jcapimin.c jaricom.c jfdctfst.c jdmainct.c jctrans.c jchuff.c jcdctmgr.c jmemnobs.c jutils.c jerror.c jddctmgr.c jdcoefct.c jcparam.c jcarith.c jcapistd.c jcmarker.c jdinput.c jccoefct.c jdpostct.c jquant2.c jdarith.c jdatadst.c jdmarker.c jcprepct.c jidctint.c jfdctflt.c jcmainct.c jquant1.c jdtrans.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_parser.c usbh_hid_keybd.c usbh_hid_mouse.c
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c usbh_core.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c queue.c croutine.c timers.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.1.0
